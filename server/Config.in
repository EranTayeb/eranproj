## server/Config.in
```kconfig
config BR2_PACKAGE_SERVER
    bool "eranserver"
    help
        server package.

        https://server.xyz
```
